## config/boards/shields/test33/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_TEST33
    bool "Test 3x3 Shield"
```
